options:
  parameters:
    author: LDAC Project Team
    comment: Ultimate LDAC codec test with 16 functional blocks - OPTIMIZED VERSION
    description: Optimized LDAC Encoder/Decoder with Enhanced Quality Features and Comprehensive Monitoring
    generate_options: no_gui
    id: test_ldac_ultimate
    output_language: python
    run_options: run
    title: Ultimate LDAC Optimized Codec System - 16 Blocks with Monitoring
  states: {}

blocks:
- name: ldac_mtu
  id: variable
  parameters:
    comment: |-
      BLOCK #3: Maximum Transmission Unit
      Frame packing size for optimized encoding
      1024 bytes provides best quality/latency balance
    value: '1024'
  states: {}
- name: ldac_quality
  id: variable
  parameters:
    comment: |-
      BLOCK #2: LDAC Quality Setting
      0 = High Quality (~990 kbps, near-transparent)
      1 = Standard Quality (~660 kbps)
      2 = Mobile Quality (~330 kbps, connection priority)
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      BLOCK #1: Sample Rate Variable
      Professional audio sample rate (48 kHz)
      Used throughout optimized codec pipeline
    value: '48000'
  states: {}
- name: blocks_deinterleave_0
  id: blocks_deinterleave
  parameters:
    comment: |-
      BLOCK #13: Deinterleave to L/R Channels
      Separates optimized decoded signal
      into independent stereo channels
      Prepares for high-quality WAV output
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      BLOCK #9: Encoded Bitstream File Sink
      Saves optimized LDAC encoded data
      High-quality compressed bitstream
    file: /home/joelj/ldac_project/encoded_optimized.ldac
    type: byte
  states: {}
- name: blocks_interleave_0
  id: blocks_interleave
  parameters:
    comment: |-
      BLOCK #6: Interleave L/R Channels
      Merges stereo channels for optimized encoding
      Format: LRLRLR... (LDAC internal format)
      Preserves spatial information
    type: float
  states: {}
- name: blocks_null_sink_monitor_decoded
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #12: Decoded Signal Monitor
      Verifies optimized decoder output quality
      Monitors enhanced audio stream
    type: float
  states: {}
- name: blocks_null_sink_monitor_encoded
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #10: Encoded Stream Monitor
      Monitors optimized compressed bitstream
      Enables bitrate and quality verification
    type: byte
  states: {}
- name: blocks_null_sink_monitor_input
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #5: Input Monitor (Left Channel)
      Non-intrusive signal monitoring point
      Enables real-time quality verification
    type: float
  states: {}
- name: blocks_null_sink_monitor_interleaved
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #7: Interleaved Signal Monitor
      Verifies stereo merge integrity
      Quality check before encoding stage
    type: float
  states: {}
- name: blocks_null_sink_monitor_output_left
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #14: Output Monitor (Left Channel)
      Final quality check for left channel
      Ensures optimized audio integrity
    type: float
  states: {}
- name: blocks_null_sink_monitor_output_right
  id: blocks_null_sink
  parameters:
    comment: |-
      BLOCK #15: Output Monitor (Right Channel)
      Final quality check for right channel
      Ensures optimized audio integrity
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: |-
      BLOCK #16: Stereo WAV File Sink
      Writes optimized decoded audio to file
      Format: 16-bit PCM stereo, 48 kHz
      Professional-grade output quality
    file: /home/joelj/ldac_project/decoded_optimized.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      BLOCK #4: Stereo WAV File Source
      Reads high-quality input audio
      Converts to float for optimized processing
    file: /home/joelj/ldac_project/input_48k.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: ldac_ldac_decoder_real_cpp_0
  id: ldac_ldac_decoder_real_cpp
  parameters:
    alias: LDAC Decoder (Optimized)
    comment: |-
      BLOCK #11: LDAC Optimized Decoder
      Enhanced decoder with audio improvements

      Features: Crossfading, noise reduction, DC removal

      Working:
      1. Frame Sync: Identifies frame boundaries
      2. Header Parse: Reads audio parameters
      3. Entropy Decode: Reverses compression
      4. Dequantization: Restores coefficients precisely
      5. Inverse MDCT: Frequency to time domain
      6. Enhancement: Crossfading + smoothing

      Input: LDAC encoded bytes
      Output: Clean, enhanced float samples
  states: {}
- name: ldac_ldac_encoder_real_cpp_0
  id: ldac_ldac_encoder_real_cpp
  parameters:
    alias: LDAC Encoder (Optimized)
    channels: '2'
    comment: |-
      BLOCK #8: LDAC Optimized Encoder
      Advanced encoder with F32 precision

      Features: Direct float processing, minimal latency

      Working:
      1. Windowing: Overlap-add for smooth transitions
      2. MDCT: Time to frequency domain transform
      3. Psychoacoustic Model: Perceptual masking
      4. Quantization: F32 precision (lossless internal)
      5. Entropy Coding: Efficient compression

      Input: Interleaved float samples (LRLRLR...)
      Output: High-quality LDAC bitstream
    mtu: ldac_mtu
    quality: ldac_quality
    sample_rate: samp_rate
  states: {}

connections:
- [blocks_deinterleave_0, '0', blocks_null_sink_monitor_output_left, '0']
- [blocks_deinterleave_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_deinterleave_0, '1', blocks_null_sink_monitor_output_right, '0']
- [blocks_deinterleave_0, '1', blocks_wavfile_sink_0, '1']
- [blocks_interleave_0, '0', blocks_null_sink_monitor_interleaved, '0']
- [blocks_interleave_0, '0', ldac_ldac_encoder_real_cpp_0, '0']
- [blocks_wavfile_source_0, '0', blocks_interleave_0, '0']
- [blocks_wavfile_source_0, '0', blocks_null_sink_monitor_input, '0']
- [blocks_wavfile_source_0, '1', blocks_interleave_0, '1']
- [ldac_ldac_decoder_real_cpp_0, '0', blocks_deinterleave_0, '0']
- [ldac_ldac_decoder_real_cpp_0, '0', blocks_null_sink_monitor_decoded, '0']
- [ldac_ldac_encoder_real_cpp_0, '0', blocks_file_sink_0, '0']
- [ldac_ldac_encoder_real_cpp_0, '0', blocks_null_sink_monitor_encoded, '0']
- [ldac_ldac_encoder_real_cpp_0, '0', ldac_ldac_decoder_real_cpp_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
